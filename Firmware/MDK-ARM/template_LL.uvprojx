# Keil uVision project template_LL.uvprojx, settings and files
target template_LL (5060960::V5.06 update 7 (build 960)::.\ARM_Compiler_5.06u7)
  device: STM32H750VBTx STMicroelectronics
  pack: Keil.STM32H7xx_DFP.3.1.0
  cpu: IRAM(0x20000000-0x2001FFFF) IRAM2(0x24000000-0x2407FFFF) IROM(0x8000000-0x801FFFF) CLOCK(12000000) FPU3(DFPU) CPUTYPE("Cortex-M7") ELITTLE TZ
  output: template_LL +hex
  c flags: Optim=3 OneElfS=1 uC99=1 uGnu=1 v6Lang=5 v6LangP=3 wLevel=2
  c define: STM32H750xx,USE_FULL_LL_DRIVER,USE_FULL_ASSERT=1U,HSE_VALUE=25000000,HSE_STARTUP_TIMEOUT=100,LSE_STARTUP_TIMEOUT=5000,LSE_VALUE=32768,EXTERNAL_CLOCK_VALUE=12288000,HSI_VALUE=64000000,LSI_VALUE=32000,VDD_VALUE=3300,CORE_CM7
  c include: ../Inc;../Drivers/STM32H7xx_HAL_Driver/Inc;../Drivers/CMSIS/Device/ST/STM32H7xx/Include;../Drivers/CMSIS/Include;../FreeRTOS/Inc;../FreeRTOS/Portable;../FreeRTOS/Src;../FreeRTOS/include;../FreeRTOS/CLI
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x24000000 size 0x80000
  group Application/MDK-ARM
    ./: startup_stm32h750xx.s
  group Application/User
    ../Src/: Led.c Usart1.c Lcd.c main.c gpio.c spi.c usart.c stm32h7xx_it.c
    ../FreeRTOS/Inc/: FreeRTOSConfig.h
  group Drivers/CMSIS
    ../Src/: system_stm32h7xx.c
  group Drivers/STM32H7xx_HAL_Driver
    ../Drivers/STM32H7xx_HAL_Driver/Src/: stm32h7xx_ll_exti.c stm32h7xx_ll_gpio.c stm32h7xx_ll_rcc.c stm32h7xx_ll_utils.c stm32h7xx_ll_spi.c stm32h7xx_ll_bdma.c stm32h7xx_ll_usart.c stm32h7xx_ll_dma.c stm32h7xx_ll_pwr.c
  group FreeRTOS/Src
    ../FreeRTOS/Src/: event_groups.c heap_4.c list.c queue.c tasks.c timers.c croutine.c
  group FreeRTOS/Portable
    ../FreeRTOS/Portable/: port.c
  group micro_shell
    ../FreeRTOS/CLI/: ansi.c ansi_port.c nr_micro_shell.c my_shell_func.c nr_micro_shell_commands.c
software components: CMSIS:CORE 4.3.0
